ORGANIZATION_BLOCK MAIN:OB1
TITLE=

BEGIN
NETWORK 1
LD Q0.0
A I0.2
O I0.1
A I0.0
= Q0.0

NETWORK 2
LDN Q0.0
= Q0.1

NETWORK 3
LD Q0.0
= Q0.2

END_ORGANIZATION_BLOCK

